FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
PR := "${PR}.ic0"

